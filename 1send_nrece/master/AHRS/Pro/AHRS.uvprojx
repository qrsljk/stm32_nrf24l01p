# Keil uVision project AHRS.uvprojx, settings and files
target AHRS (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AHRS +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,MPL_LOG_NDEBUG=1,MPU9250,EMPL,USE_DMP,EMPL_TARGET_STM32F103xB
  c include: ..\Core;..\FWLib\inc;..\Pro;..\Drive\delay;..\Drive\nvic;..\Drive\uart;..\Drive\led;..\Drive\exti;..\Drive\tim;..\Drive\spi;..\Drive\nrf24l01p
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Pro
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_md.s
  group Drive
    ../Drive/delay/: delay.c
    ../Drive/nvic/: nvic.c
    ../Drive/uart/: uart.c
    ../Drive/led/: led.c
    ../Drive/exti/: exti.c
    ../Drive/tim/: tim.c
    ../Drive/spi/: spi.c
    ../Drive/nrf24l01p/: nrf24l01p.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
